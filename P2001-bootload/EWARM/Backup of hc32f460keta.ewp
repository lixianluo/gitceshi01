# IAR project Backup of hc32f460keta.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: HC32F46x; __DEBUG
  ICCARM.CCIncludePath2: ..\common; ..\source; ..\driver\src; ..\driver\inc; ..\source\AlgorithmBoard; ..\source\Battery; ..\source\Board2Board; ..\source\CAN; ..\source\DMA; ..\source\DriveControl; ..\source\Encoder; ..\source\Error; ..\source\GPIO; ..\source\IMU; ..\source\Mode; ..\source\Pedal; ..\source\ServoMotor; ..\source\Timer; ..\source\UART; ..\source\Ultrasonic
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f460keta_boot.bin
  ILINK.IlinkOutputFile: hc32f460keta.out
  ILINK.IlinkIcfFile: config\HC32F46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HC32F46x
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: hc32f460keta.srec
  group common
    ./: startup_hc32f460keta.s
    ../common/: system_hc32f460keta.c
  group driver
    ../driver/src/: hc32f46x_can.c hc32f46x_clk.c hc32f46x_crc.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c hc32f46x_sram.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group source
    ../source/AlgorithmBoard/: AlgorithmBoard.c
    ../source/Board2Board/: Board2Board.c
    ../source/CAN/: can.c
    ../source/: can_iap.c flash.c main.c sw_timer.c task.c tnd_fota.c version.c wdt.c ymodem_ota.c
    ../source/GPIO/: gpio.c
    ../source/Timer/: timer.c
    ../source/UART/: uart.c
