# Keil uVision project HC32F460KETA.uvprojx, settings and files
target HC32F460KETA_Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: IROM(0x00000000,0x80000) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: HC32F460KETA
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB,__TARGET_FPU_VFP, ARM_MATH_CM4
  c misc: --diag_suppress=186
  c include: ..\common;..\source;..\driver\src;..\driver\inc;..\source\Timer;..\source\GPIO;..\source\DMA;..\source\UART;..\source\AlgorithmBoard;..\source\Encoder;..\source\IMU;..\source\Battery;..\source\Board2Board;..\source\CAN;..\source\DriveControl;..\source\Error;..\source\Mode;..\source\Pedal;..\source\ServoMotor;..\source\Ultrasonic
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f460keta.s
    ../common/: system_hc32f460keta.c
  group source
    ../source/: main.c task.c sw_timer.c timestamp.c debug.c wdt.c version.c
    ../source/Timer/: timer.c
    ../source/GPIO/: gpio.c
    ../source/UART/: uart.c
    ../source/AlgorithmBoard/: AlgorithmBoard.c
    ../source/CAN/: can.c
    ../source/Encoder/: encoder.c
    ../source/IMU/: imu.c
    ../source/Board2Board/: Board2Board.c
    ../source/Battery/: battery.c
    ../source/DriveControl/: DriveControl.c
    ../source/Mode/: mode.c
    ../source/ServoMotor/: servo_motor.c
    ../source/Error/: error.c
    ../source/Pedal/: acc_pedal.c
    ../source/Ultrasonic/: ultrasonic.c
  group driver
    ../driver/src/: hc32f46x_sram.c hc32f46x_clk.c hc32f46x_pwc.c hc32f46x_utility.c hc32f46x_interrupts.c hc32f46x_timer0.c hc32f46x_gpio.c hc32f46x_efm.c hc32f46x_dmac.c hc32f46x_usart.c hc32f46x_timer4_cnt.c hc32f46x_wdt.c hc32f46x_can.c hc32f46x_timera.c
target HC32F460KETA_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: as above
  output: HC32F460KETA +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F46x
  c misc: --diag_suppress=186
  c include: ..\..\common;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
